# Keil uVision project GPS.uvproj, settings and files
target GPS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPS
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: ..\User;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\owner\h;..\Route;..\menu;..\General_Functions\h;..\menu\h;..\FatFS_R0.10;..\FatFS_R0.10\option;..\update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_exti.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group owner
    ../owner/c/: SysTick.c usart.c init.c lcd.c pwm.c key.c measure.c sys.c sa.c can_database.c Command.c compass.c mecanum.c guide.c can.c accurate.c tim.c obstacle.c flash.c parameter_setting.c
  group General_Functions
    ../General_Functions/c/: mymath.c pid.c
  group Menu
    ../menu/: func.c list.c M_Colour.c M_SA.c M_COMPASS.c M_MOTOR.c M_CAMER.c M_ADC.c M_MOVE.c
